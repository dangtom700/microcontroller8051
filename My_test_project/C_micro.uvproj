# Keil uVision project C_micro.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89LS53 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x2FFF) CLOCK(12000000) MODA2
  output: C_micro +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c delay.h feature.h README.txt STARTUP.A51 binary_display.txt blink_pattern.txt digital_lock.txt number_muxer.txt test_blink.txt
