# Keil uVision project FinalProjectold.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S8253 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x2FFF) CLOCK(24000000) MODA2
  output: FinalProject +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c display.h README.txt RPMtestreadnew.h control.h RPMtestread.h update.h Code_NOV_28_1248.txt Code_Nov28_v1_1248.txt
