# Keil uVision project test_drive.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S8253 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x2FFF) CLOCK(24000000) MODA2
  output: test_drive +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: blinking.asm test_blink.txt blinking.txt
